Commit message: walls added

File: models/ground.urdf (robot description, URDF)
Before this commit: robot ground, 1 links, 0 joints
Links:
- link baseLink: geometry collision box size=10 10 0.2; visual box size=10 10 0.2
